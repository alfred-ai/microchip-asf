# IAR project led_toggle_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; BOARD=SAMD11_XPLAINED_PRO; __SAMD11D14AM__
  ICCARM.CCIncludePath2: ../../../../drivers/system/power; ../../../../drivers/system/reset; ../../../../utils/preprocessor; ../../../../utils; ../../../../boards/samd11_xplained_pro; ../../../../drivers/port; ../../../../boards; ../../../../drivers/system/interrupt/system_interrupt_samd10_d11; ../..; ../../../../../common/utils; ../../../../utils/cmsis/samd11/source; ../../../../drivers/system/interrupt; ../../../../drivers/system/clock/clock_samd10_d11; ../../../../drivers/system/power/power_sam_d_r; ../../../../drivers/system/reset/reset_sam_d_r; ../../../../utils/cmsis/samd11/include; ../../../../../common/boards; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../utils/header_files; ..; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: led_toggle_flash.bin
  ILINK.IlinkOutputFile: led_toggle_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd10_d11
    ../../../../drivers/system/clock/clock_samd10_d11/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../drivers/system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/samd11_xplained_pro
    ../../../../boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
  group sam0/utils
    ../../../../utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd11/source
    ../../../../utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../utils/cmsis/samd11/include/: samd11d14as.h samd11d14am.h samd11.h samd11c14a.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../utils/cmsis/samd11/include/component/: tc.h pm.h wdt.h eic.h gclk.h sercom.h pac.h ac.h nvmctrl.h hmatrixb.h rtc.h evsys.h dmac.h port.h usb.h dsu.h adc.h sysctrl.h tcc.h dac.h mtb.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../utils/cmsis/samd11/include/pio/: samd11c14a.h samd11d14as.h samd11d14am.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../utils/cmsis/samd11/include/instance/: pac2.h pac0.h sercom1.h rtc.h mtb.h wdt.h gclk.h pm.h evsys.h tc1.h sercom0.h dac.h sbmatrix.h adc.h tcc0.h nvmctrl.h sercom2.h tc2.h port.h usb.h ac.h dmac.h eic.h sysctrl.h dsu.h pac1.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: stringz.h mrepeat.h mrecursion.h tpaste.h preprocessor.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/applications/led_toggle
    ../../: led_toggle.c
  group sam0/applications/led_toggle/samd11_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/applications/led_toggle/samd11_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
