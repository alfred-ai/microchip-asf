# IAR project dac_sound_player_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EVENTS_INTERRUPT_HOOKS_MODE=true; TC_ASYNC=true; DAC_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; __SAML21J18A__; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../drivers/dac; ../../../../drivers/port; ../../../../drivers/system/reset; ../../../../drivers/system/interrupt/system_interrupt_saml21; ../../../../drivers/dac/dac_sam_l; ..; ../../../../utils/preprocessor; ../../../../utils; ../../../../drivers/system/power; ../../../../boards; ../../../../drivers/events/events_sam_l_c; ../../../../drivers/tc/tc_sam_l_c; ../../../../../common/utils; ../../../../drivers/system/interrupt; ../../../../drivers/system/power/power_sam_l; ../..; ../../../../drivers/tc; ../../../../utils/header_files; ../../../../boards/saml21_xplained_pro; ../../../../utils/cmsis/saml21/include; ../../../../drivers/system/clock/clock_saml21; ../../../../../common/boards; ../../../../drivers/system/reset/reset_sam_l; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../drivers/events; ../../../../utils/cmsis/saml21/source; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dac_sound_player_flash.bin
  ILINK.IlinkOutputFile: dac_sound_player_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../drivers/system/clock/clock_saml21/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/dac
    ../../../../drivers/dac/: dac.h dac_callback.h
  group sam0/drivers/dac/dac_sam_l
    ../../../../drivers/dac/dac_sam_l/: dac.c dac_callback.c dac_feature.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/tc
    ../../../../drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/events
    ../../../../drivers/events/: events_hooks.c events.h events_hooks.h events_common.h
  group sam0/drivers/events/events_sam_l_c
    ../../../../drivers/events/events_sam_l_c/: events.c
  group sam0/boards/saml21_xplained_pro
    ../../../../boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../utils/cmsis/saml21/include/: saml21.h saml21g16a.h saml21e15a.h saml21e16a.h saml21e17a.h saml21j17a.h saml21g18a.h saml21j16a.h saml21j18a.h saml21g17a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../utils/cmsis/saml21/include/component/: eic.h trng.h pac.h ccl.h nvmctrl.h osc32kctrl.h gclk.h rstc.h sercom.h supc.h port.h tc.h mclk.h wdt.h dac.h mtb.h dsu.h oscctrl.h tcc.h tal.h ac.h opamp.h pm.h evsys.h adc.h usb.h rtc.h dmac.h aes.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../utils/cmsis/saml21/include/instance/: trng.h mtb.h wdt.h rstc.h sercom2.h sercom4.h dmac.h nvmctrl.h ac.h tc1.h adc.h opamp.h tc3.h dac.h dsu.h supc.h mclk.h tc4.h gclk.h port.h eic.h ccl.h tc0.h rtc.h sercom1.h tcc0.h tal.h pac.h evsys.h tc2.h aes.h tcc2.h oscctrl.h sercom3.h sercom5.h usb.h sercom0.h osc32kctrl.h pm.h tcc1.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../utils/cmsis/saml21/include/pio/: saml21g16a.h saml21e15a.h saml21j16a.h saml21j18a.h saml21g18a.h saml21g17a.h saml21e16a.h saml21e17a.h saml21j17a.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/applications/dac_sound_player
    ../../: dac_sound_player.c data.x
  group sam0/applications/dac_sound_player/saml21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/applications/dac_sound_player/saml21_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
