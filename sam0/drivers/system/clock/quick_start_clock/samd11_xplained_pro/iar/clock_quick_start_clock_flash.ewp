# IAR project clock_quick_start_clock_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; BOARD=SAMD11_XPLAINED_PRO; __SAMD11D14AM__
  ICCARM.CCIncludePath2: ../../../../power; ../../../../reset; ../../../../../../utils/preprocessor; ../../../../../../utils; ../../../../../../boards/samd11_xplained_pro; ../..; ../../../../../port; ../../../../../../boards; ../../../../interrupt/system_interrupt_samd10_d11; ../../../../../../../common/utils; ../../../../../../utils/cmsis/samd11/source; ../../../../interrupt; ../../../clock_samd10_d11; ../../../../power/power_sam_d_r; ..; ../../../../reset/reset_sam_d_r; ../../../../../../utils/cmsis/samd11/include; ../../../../../../../common/boards; ../../../../pinmux; ../../../..; ../../../../../../utils/header_files; ../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: clock_quick_start_clock_flash.bin
  ILINK.IlinkOutputFile: clock_quick_start_clock_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd11/source
    ../../../../../../utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../../../utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../../../utils/cmsis/samd11/include/: samd11d14am.h samd11d14as.h samd11c14a.h samd11.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../../../utils/cmsis/samd11/include/component/: nvmctrl.h ac.h dac.h dmac.h mtb.h usb.h dsu.h tc.h sercom.h rtc.h sysctrl.h hmatrixb.h wdt.h pac.h adc.h evsys.h tcc.h port.h eic.h gclk.h pm.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../../../utils/cmsis/samd11/include/pio/: samd11d14am.h samd11c14a.h samd11d14as.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../../../utils/cmsis/samd11/include/instance/: sbmatrix.h nvmctrl.h gclk.h evsys.h sercom2.h sercom1.h sercom0.h ac.h tc1.h usb.h pm.h mtb.h dac.h sysctrl.h wdt.h tc2.h eic.h port.h pac2.h dsu.h rtc.h pac1.h dmac.h pac0.h tcc0.h adc.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: tpaste.h mrepeat.h mrecursion.h stringz.h preprocessor.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/drivers/system
    ../../../../: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../: clock.h gclk.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../: qs_clock_source.c
  group sam0/drivers/system/clock/quick_start_clock/samd11_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/system/clock/quick_start_clock/samd11_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system/clock/clock_samd10_d11
    ../../../clock_samd10_d11/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../power/power_sam_d_r/: power.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samd11_xplained_pro
    ../../../../../../boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
