# IAR project interrupt_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; BOARD=SAMD11_XPLAINED_PRO; __SAMD11D14AM__
  ICCARM.CCIncludePath2: ../../../../power; ../../../../reset; ../../../../../../utils/preprocessor; ..; ../../../../../../utils; ../../../../../../boards/samd11_xplained_pro; ../../../../../port; ../../../../../../boards; ../..; ../../../system_interrupt_samd10_d11; ../../../../../../../common/utils; ../../../../../../utils/cmsis/samd11/source; ../../..; ../../../../clock/clock_samd10_d11; ../../../../power/power_sam_d_r; ../../../../reset/reset_sam_d_r; ../../../../../../utils/cmsis/samd11/include; ../../../../../../../common/boards; ../../../../pinmux; ../../../..; ../../../../../../utils/header_files; ../../../../clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: interrupt_quick_start_flash.bin
  ILINK.IlinkOutputFile: interrupt_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd11/source
    ../../../../../../utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../../../utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../../../utils/cmsis/samd11/include/: samd11d14am.h samd11d14as.h samd11c14a.h samd11.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../../../utils/cmsis/samd11/include/component/: nvmctrl.h ac.h dac.h dmac.h mtb.h usb.h dsu.h hmatrixb.h tc.h sercom.h rtc.h sysctrl.h wdt.h pac.h eic.h adc.h evsys.h tcc.h port.h gclk.h pm.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../../../utils/cmsis/samd11/include/pio/: samd11d14am.h samd11d14as.h samd11c14a.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../../../utils/cmsis/samd11/include/instance/: sbmatrix.h nvmctrl.h gclk.h evsys.h sercom2.h sercom1.h sercom0.h ac.h tc1.h usb.h pm.h mtb.h dac.h sysctrl.h wdt.h eic.h port.h pac2.h rtc.h pac1.h dmac.h pac0.h tcc0.h dsu.h adc.h tc2.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: tpaste.h mrepeat.h mrecursion.h stringz.h preprocessor.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/drivers/system
    ../../../../: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd10_d11
    ../../../../clock/clock_samd10_d11/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../: qs_system_interrupt.c
  group sam0/drivers/system/interrupt/quick_start/samd11_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/system/interrupt/quick_start/samd11_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../power/power_sam_d_r/: power.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samd11_xplained_pro
    ../../../../../../boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
