# IAR project rww_eeprom_emulator_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; USART_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAML21J18A__; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../drivers/system/power; ../../../../../../../drivers/system/reset; ../../../../../../../drivers/system/interrupt/system_interrupt_saml21; ../../../../../../../utils/preprocessor; ../../..; ../..; ../../../../../../../drivers/nvm; ../../../../../../../drivers/sercom; ../../../../../../../drivers/port; ../../../../../../../boards; ../../../../../../../drivers/sercom/usart; ../../../../../../../../common/services/serial; ../../../../../../../utils; ../../../../../../../../common/utils; ../../../../../../../drivers/system/interrupt; ../../../../../../../drivers/system/power/power_sam_l; ../../../../../../../utils/header_files; ../../../../../../../boards/saml21_xplained_pro; ../../../../../../../utils/cmsis/saml21/include; ../../../../../../../drivers/system/clock/clock_saml21; ../../../../../../../../common/boards; ../../../../../../../drivers/system/reset/reset_sam_l; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system; ..; ../../../../../../../utils/cmsis/saml21/source; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rww_eeprom_emulator_unit_test_flash.bin
  ILINK.IlinkOutputFile: rww_eeprom_emulator_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../drivers/system/clock/clock_saml21/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/sercom
    ../../../../../../../drivers/sercom/: sercom.c sercom_interrupt.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../../utils/cmsis/saml21/include/: saml21g17a.h saml21.h saml21e17a.h saml21j18a.h saml21j17a.h saml21e16a.h saml21j16a.h saml21g16a.h saml21g18a.h saml21e15a.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../../utils/cmsis/saml21/include/pio/: saml21g16a.h saml21e17a.h saml21j16a.h saml21g18a.h saml21j18a.h saml21j17a.h saml21g17a.h saml21e15a.h saml21e16a.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../../utils/cmsis/saml21/include/instance/: ccl.h ac.h trng.h pac.h eic.h supc.h dmac.h rtc.h adc.h tcc1.h dsu.h pm.h nvmctrl.h tc2.h evsys.h wdt.h sercom0.h tc0.h oscctrl.h sercom4.h osc32kctrl.h rstc.h tc4.h tcc0.h opamp.h usb.h sercom2.h tc3.h gclk.h tc1.h sercom1.h tcc2.h sercom3.h sercom5.h port.h mtb.h tal.h aes.h dac.h mclk.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../../utils/cmsis/saml21/include/component/: pac.h eic.h evsys.h mclk.h nvmctrl.h mtb.h adc.h aes.h tc.h tal.h port.h dsu.h opamp.h osc32kctrl.h sercom.h rstc.h supc.h gclk.h pm.h rtc.h usb.h dac.h wdt.h tcc.h ac.h dmac.h trng.h oscctrl.h ccl.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h stringz.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../../../boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group sam0/services/eeprom/emulator/rwwee_array
    ../../../: rww_eeprom.c rww_eeprom.h
  group sam0/services/eeprom/emulator/rwwee_array/unit_test
    ../../: unit_test.c
  group sam0/services/eeprom/emulator/rwwee_array/unit_test/saml21j18a_saml21_xplained_pro
    ../: conf_board.h conf_rwwee.h conf_test.h conf_clocks.h
  group sam0/services/eeprom/emulator/rwwee_array/unit_test/saml21j18a_saml21_xplained_pro/iar
    ./: asf.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start
    ../../../quick_start/: qs_emulator_basic.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
