# IAR project ssd1306_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; __SAML21J18A__; SPI_CALLBACK_MODE=true; BOARD=SAML21_XPLAINED_PRO; SYSTICK_MODE
  ICCARM.CCIncludePath2: ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/drivers/system/reset; ../../../../../../../sam0/boards/saml21_xplained_pro; ../../../../../../../sam0/utils/preprocessor; ../../../../../../services/delay; ../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../sam0/utils; ..; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/boards; ../../..; ../../../../../../../common/utils; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ../../../../../../../sam0/drivers/sercom; ../../../../../../services/delay/sam0; ../../../../../../../sam0/utils/cmsis/saml21/include; ../../../../../../../sam0/drivers/system/clock/clock_saml21; ../../../../../../../common/boards; ../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../sam0/drivers/system; ../../../../../../../sam0/utils/cmsis/saml21/source; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ssd1306_example_flash.bin
  ILINK.IlinkOutputFile: ssd1306_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/components/display/ssd1306
    ../../../: ssd1306.c ssd1306.h
  group common2/components/display/ssd1306/example
    ../../: ssd1306_example.c
  group common2/components/display/ssd1306/example/saml21_xplained_pro
    ../: conf_board.h conf_ssd1306.h conf_spi.h conf_clocks.h
  group common2/components/display/ssd1306/example/saml21_xplained_pro/iar
    ./: asf.h
  group common2/services/delay
    ../../../../../../services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../services/delay/sam0/: systick_counter.c systick_counter.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../../../sam0/boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../sam0/drivers/system/clock/clock_saml21/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/spi
    ../../../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi.h spi_interrupt.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../../sam0/utils/cmsis/saml21/include/: saml21j17a.h saml21.h saml21g16a.h saml21j18a.h saml21e15a.h saml21j16a.h saml21g18a.h saml21g17a.h saml21e17a.h saml21e16a.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../../sam0/utils/cmsis/saml21/include/component/: evsys.h osc32kctrl.h tc.h supc.h port.h dsu.h usb.h adc.h aes.h mclk.h pac.h trng.h mtb.h tcc.h pm.h ccl.h opamp.h ac.h dmac.h wdt.h oscctrl.h dac.h rtc.h sercom.h eic.h tal.h nvmctrl.h rstc.h gclk.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../../sam0/utils/cmsis/saml21/include/pio/: saml21e16a.h saml21g16a.h saml21e17a.h saml21g17a.h saml21j16a.h saml21e15a.h saml21j17a.h saml21j18a.h saml21g18a.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../../sam0/utils/cmsis/saml21/include/instance/: tc2.h tc0.h sercom1.h mtb.h opamp.h osc32kctrl.h wdt.h aes.h nvmctrl.h port.h pac.h tc3.h sercom5.h rstc.h tc1.h usb.h tal.h rtc.h dmac.h dac.h dsu.h eic.h mclk.h sercom4.h ac.h tc4.h adc.h sercom2.h gclk.h tcc1.h sercom0.h pm.h ccl.h evsys.h supc.h oscctrl.h trng.h tcc2.h sercom3.h tcc0.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: tpaste.h mrepeat.h mrecursion.h preprocessor.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
