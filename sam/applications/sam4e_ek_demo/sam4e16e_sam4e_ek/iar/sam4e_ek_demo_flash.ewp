# IAR project sam4e_ek_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: HTTP_USED=1; FREERTOS_USED; __SAM4E16E__; __FREERTOS__; BOARD=SAM4E_EK; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../utils/header_files; ../..; ../../../../../thirdparty/lwip/lwip-1.4.1/src/include/ipv4; ../../../../drivers/rstc; ../../../../utils/preprocessor; ../../../../components/ethernet_phy/ksz8051mnl; ../../../../drivers/pmc; ../../../../components/display/ili93xx; ../../network; ../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f; ../../../../../common/components/touch/qt/qt_i2c; ../../../../../common/services/spi/sam_spi; ../../../../../thirdparty/lwip/lwip-1.4.1/src/include; ../../../../drivers/ebi/smc; ../../../../../thirdparty/lwip/lwip-port-1.4.1/sam/include/netif; ../../../../utils/fpu; ../../../../../common/services/twi; ../../../../../common/services/serial; ../../../../../common/services/clock; ../../network/httpserver_raw; ../../../../drivers/spi; ../../../../utils/cmsis/sam4e/source/templates; ..; ../../../../../common/utils; ../../../../../thirdparty/lwip/lwip-1.4.1/src/include/lwip; ../../../../drivers/gmac; ../../../../components/resistive_touch/ads7843; ../../../../../thirdparty/freertos/freertos-7.3.0/source/include; ../../../../boards; ../../../../components/display/aat31xx; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/services/sleepmgr; ../../../../drivers/pdc/pdc_uart_example; ../../../../drivers/pio; ../../../../utils/cmsis/sam4e/include; ../../../../../common/services/gpio; ../../../../../common/services/delay; ../../../../drivers/uart; ../../../../utils; ../../../../drivers/dacc; ../../../../drivers/tc; ../../../../../common/services/spi; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../../services/resistive_touch; ../../../../../common/components/touch/qt/qt_i2c/device_specific; ../../../../../common/services/ioport; ../../../../drivers/pdc; ../../../../../thirdparty/lwip/lwip-port-1.4.1/sam/include; ../../../../drivers/afec; ../../../../boards/sam4e_ek; ../../../../drivers/usart; ../../../../drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sam4e_ek_demo_flash.bin
  ILINK.IlinkOutputFile: sam4e_ek_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/applications/sam4e_ek_demo
    ../../: task_webserver.c task_gfx.c task_qtouch_cpn.c task_dsp.c main.c FreeRTOSConfig.h task_demo.h logo_atmel.h sound.h lwipopts.h
  group sam/applications/sam4e_ek_demo/network
    ../../network/: timer_mgt_sam.c ethernet_sam.c timer_mgt_sam.h ethernet_sam.h
  group sam/applications/sam4e_ek_demo/network/httpserver_raw
    ../../network/httpserver_raw/: cgi.c fsdata.c fs.c httpd.c style.h fs.h index.h fsdata.h favicon.h jqflot.h cgi.h atmel.h jquery.h httpd.h excan.h
  group sam/applications/sam4e_ek_demo/sam4e16e_sam4e_ek
    ../: conf_ili93xx.h conf_uart_serial.h conf_qt_i2c.h conf_board.h conf_eth.h conf_sleepmgr.h conf_aat31xx.h conf_clock.h conf_ads7843.h conf_spi_master.h
  group sam/applications/sam4e_ek_demo/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/afec
    ../../../../drivers/afec/: afec.c afec.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group sam/drivers/twi
    ../../../../drivers/twi/: twi.c twi.h
  group sam/drivers/rstc
    ../../../../drivers/rstc/: rstc.c rstc.h
  group sam/drivers/rstc/example1
    ../../../../drivers/rstc/example1/: rstc_example1.h
  group sam/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/dacc
    ../../../../drivers/dacc/: dacc.c dacc.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/gmac
    ../../../../drivers/gmac/: gmac_phy.c gmac.h
  group sam/drivers/spi
    ../../../../drivers/spi/: spi.c spi.h
  group sam/components/display/ili93xx
    ../../../../components/display/ili93xx/: ili93xx.c ili9341_regs.h ili9325_regs.h ili93xx.h
  group sam/components/display/aat31xx
    ../../../../components/display/aat31xx/: aat31xx.c aat31xx.h
  group sam/components/resistive_touch/ads7843
    ../../../../components/resistive_touch/ads7843/: ads7843.c ads7843.h
  group sam/components/ethernet_phy
    ../../../../components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/ksz8051mnl
    ../../../../components/ethernet_phy/ksz8051mnl/: ethernet_phy.c ethernet_phy.h
  group sam/boards/sam4e_ek
    ../../../../boards/sam4e_ek/: init.c sam4e_ek.h led.h
  group sam/utils
    ../../../../utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c system_sam4e.h exceptions.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../utils/cmsis/sam4e/include/: sam4e16e.h sam4e8c.h sam4e8e.h sam4e8cb.h sam4e16c.h sam4e16cb.h sam4e.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../utils/cmsis/sam4e/include/instance/: afec0.h matrix.h smc.h dacc.h hsmci.h tc2.h acc.h can1.h chipid.h rtc.h tc1.h spi.h twi0.h can0.h gmac.h uart0.h piod.h rswdt.h pwm.h piob.h pioc.h tc0.h rstc.h dmac.h twi1.h supc.h uart1.h pioa.h efc.h udp.h usart0.h wdt.h pioe.h aes.h cmcc.h afec1.h pmc.h gpbr.h rtt.h usart1.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../utils/cmsis/sam4e/include/pio/: sam4e16e.h sam4e16cb.h sam4e8e.h sam4e8cb.h sam4e16c.h sam4e8c.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../utils/cmsis/sam4e/include/component/: rswdt.h rtc.h matrix.h dacc.h supc.h gmac.h hsmci.h pdc.h wdt.h spi.h dmac.h usart.h udp.h tc.h gpbr.h uart.h can.h efc.h rtt.h smc.h rstc.h pio.h pwm.h cmcc.h aes.h chipid.h afec.h acc.h pmc.h twi.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h mrepeat.h preprocessor.h stringz.h
  group sam/utils/fpu
    ../../../../utils/fpu/: fpu.h
  group sam/services/resistive_touch
    ../../../../services/resistive_touch/: rtouch.c rtouch.h rtouch_ads7843.h
  group thirdparty/lwip/lwip-1.4.1/src/core
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/core/: pbuf.c dns.c lwip_timers_141.c tcp.c netif.c sys.c def.c udp.c dhcp.c memp.c tcp_in.c raw.c tcp_out.c mem.c stats.c lwip_init.c
  group thirdparty/lwip/lwip-1.4.1/src/core/ipv4
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/core/ipv4/: ip_frag.c igmp.c icmp.c autoip.c ip_addr.c inet.c ip.c inet_chksum.c
  group thirdparty/lwip/lwip-1.4.1/src/api
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/api/: netdb.c api_lib.c netbuf.c api_msg.c tcpip.c sockets.c netifapi.c err.c
  group thirdparty/lwip/lwip-1.4.1/src/netif
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.1/src/include/lwip
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/include/lwip/: snmp_asn1.h raw.h pbuf.h netbuf.h stats.h snmp_structs.h netdb.h def.h arch.h api.h snmp.h opt.h debug.h tcpip.h sockets.h netifapi.h dhcp.h memp_std.h udp.h memp.h snmp_msg.h api_msg.h sys.h tcp_impl.h mem.h netif.h sio.h tcp.h err.h dns.h init.h timers.h
  group thirdparty/lwip/lwip-1.4.1/src/include/ipv4/lwip
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/include/ipv4/lwip/: icmp.h inet.h ip_addr.h inet_chksum.h ip_frag.h ip.h autoip.h igmp.h
  group thirdparty/lwip/lwip-1.4.1/src/include/netif
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/include/netif/: etharp.h ppp_oe.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/netif
    ../../../../../thirdparty/lwip/lwip-port-1.4.1/sam/netif/: sam4e_gmac.c
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/arch
    ../../../../../thirdparty/lwip/lwip-port-1.4.1/sam/include/arch/: cc.h perf.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/netif
    ../../../../../thirdparty/lwip/lwip-port-1.4.1/sam/include/netif/: sam4e_gmac.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../thirdparty/freertos/freertos-7.3.0/source/: tasks.c FreeRTOS_CLI.c timers.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../thirdparty/freertos/freertos-7.3.0/source/include/: semphr.h projdefs.h mpu_wrappers.h list.h task.h FreeRTOS.h timers.h portable.h StackMacros.h FreeRTOS_CLI.h queue.h croutine.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/sam4e
    ../../../../../common/services/clock/sam4e/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/twi
    ../../../../../common/services/twi/: twi_master.h twi_slave.h
  group common/services/twi/sam_twi
    ../../../../../common/services/twi/sam_twi/: twi_master.h twi_slave.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/touch/qt/qt_i2c
    ../../../../../common/components/touch/qt/qt_i2c/: qt_i2c.c qt_i2c.h
  group common/components/touch/qt/qt_i2c/device_specific
    ../../../../../common/components/touch/qt/qt_i2c/device_specific/: QT2160.h
  group common/boards
    ../../../../../common/boards/: board.h
