<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ble_observer_samr34_xplained_pro_flash.ewp</path>
	</project>
</workspace>
