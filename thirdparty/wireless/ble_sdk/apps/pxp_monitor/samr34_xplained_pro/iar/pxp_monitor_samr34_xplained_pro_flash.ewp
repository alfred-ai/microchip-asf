# IAR project pxp_monitor_samr34_xplained_pro_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR34J18B Atmel ATSAMR34J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: HOST_UART_BAUDRATE_CONFIG_VALUE=921600; NENABLE_PTS; NA_BAND=1; BOARD=SAMR34_XPLAINED_PRO; LINK_LOSS_SERVICE; LLS_GATT_CLIENT; TXPS_GATT_CLIENT; IND_BAND=1; TX_POWER_SERVICE; PROXIMITY_MONITOR; KR_BAND=1; IAS_GATT_CLIENT; NEW_EVT_HANDLER; UART_FLOWCONTROL_4WIRE_MODE=true; _DEBUG_=0; TC_ASYNC=true; JPN_BAND=1; ARM_MATH_CM0PLUS=true; RANDOM_NW_ACQ=1; AS_BAND=1; ENABLE_POWER_SAVE; EU_BAND=1; AU_BAND=1; EXTINT_CALLBACK_MODE=true; IMMEDIATE_ALERT_SERVICE; BLE_MODULE=BTLC1000_ZR; CONF_PMM_ENABLE; __SAMR34J18B__; USART_CALLBACK_MODE=true; USE_SCAN_SOFT_FILTER; ENABLE_PDS=1; UART_FLOWCONTROL_6WIRE_MODE=false; SPI_CALLBACK_MODE=true; SLEEP_WALKING_ENABLED=false; SYSTICK_MODE; RTC_COUNT_ASYNC=true; BLE_DEVICE_ROLE=BLE_ROLE_CENTRAL; HOST_SLEEP_ENABLE=true
  ICCARM.CCIncludePath2: ../../../../../lorawan/sal/inc; ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../sam0/drivers/system/reset; ../../../../../../../sam0/utils/cmsis/samr34/include; ../../../../ble_profiles/pxp_monitor; ../../../../../lorawan/services/sw_timer/inc; ../../../../ble_services/ble_mgr; ../../../../../../../sam0/utils/preprocessor; ../../../../ble_services/link_loss; ../../../../../../../sam0/boards/samr34_xplained_pro; ../../../../ble_services/tx_power; ../../../../../../../sam0/utils; ../../../../services/timer; ../../../../../lorawan/services/aes/inc; ../../../../../services/common_hw_timer/sam0; ../../../config/samr34; ../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/boards; ../../../../../../../sam0/drivers/sercom/usart; ../../../../../lorawan/regparams/inc; ../../../../../../../common/services/serial; ../..; ../../../../../../../sam0/drivers/system; ../../../../services/serial/uart; ../../../../../../../sam0/drivers/tc/tc_sam_l_c; ../../../../../../../sam0/drivers/rtc; ../../../../../../../common/utils; ../../../../../../../sam0/drivers/rtc/rtc_sam_l_c; ../../../../../../../sam0/drivers/aes; ../../../../../../../sam0/drivers/system/interrupt; ..; ../../../../../lorawan/pmm/inc; ../../../../../lorawan/regparams/multiband/inc; ../../../../../../../sam0/drivers/tc; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr34; ../../../../inc; ../../../../../lorawan/tal/inc; ../../../../../../../sam0/drivers/nvm; ../../../../../../../sam0/utils/cmsis/samr34/source; ../../../../../services/common_hw_timer; ../../../../../lorawan/inc; ../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../lorawan/mac/inc; ../../../../../lorawan/hal/inc; ../../../../../../../common2/services/delay/sam0; ../../../../../lorawan/tal/sx1276/inc; ../../../../../lorawan/sys/inc; ../../../../../lorawan/services/pds/inc; ../../../../utils; ../../../../../../../common2/services/delay; ../../../../../../../common/boards; ../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../sam0/drivers/system/pinmux; ../../../../services/console; ../../../../../../../sam0/drivers/system/clock/clock_samr34; ../../../../../../../sam0/drivers/extint; ../../../../services/serial_fifo; ../../../../../../../sam0/utils/header_files; ../../../../ble_services/immediate_alert; ../../../../../services/nvm; ../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: pxp_monitor_samr34_xplained_pro_flash.bin
  ILINK.IlinkOutputFile: pxp_monitor_samr34_xplained_pro_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/samr34/iar/samr34j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/ble_sdk/lib/cm0p/iar
    ../../../../lib/cm0p/iar/: libble_sdk.a
  group thirdparty/wireless/ble_sdk/services/serial_fifo
    ../../../../services/serial_fifo/: serial_fifo.c serial_fifo.h
  group thirdparty/wireless/ble_sdk/services/timer
    ../../../../services/timer/: timer_hw.h
  group thirdparty/wireless/ble_sdk/services/timer/sam0
    ../../../../services/timer/sam0/: timer_hw.c
  group thirdparty/wireless/ble_sdk/services/serial/uart
    ../../../../services/serial/uart/: serial_drv.h
  group thirdparty/wireless/ble_sdk/services/serial/uart/sam0
    ../../../../services/serial/uart/sam0/: serial_drv.c
  group thirdparty/wireless/ble_sdk/services/console
    ../../../../services/console/: console_serial.h
  group thirdparty/wireless/ble_sdk/services/console/sam0
    ../../../../services/console/sam0/: console_serial.c
  group thirdparty/wireless/ble_sdk/src
    ../../../../src/: platform.c
  group thirdparty/wireless/ble_sdk/ble_services/tx_power
    ../../../../ble_services/tx_power/: tx_power.c tx_power.h
  group thirdparty/wireless/ble_sdk/ble_services/link_loss
    ../../../../ble_services/link_loss/: link_loss.c link_loss.h
  group thirdparty/wireless/ble_sdk/ble_services/immediate_alert
    ../../../../ble_services/immediate_alert/: immediate_alert.c immediate_alert.h
  group thirdparty/wireless/ble_sdk/ble_services/ble_mgr
    ../../../../ble_services/ble_mgr/: ble_manager.c ble_manager.h
  group thirdparty/wireless/ble_sdk/apps
    ../../../: lorawan.c
  group thirdparty/wireless/ble_sdk/apps/pxp_monitor
    ../../: pxp_monitor_app.c pxp_monitor_app.h
  group thirdparty/wireless/ble_sdk/apps/pxp_monitor/samr34_xplained_pro
    ../: conf_sw_timer.h conf_rtc.h conf_nvm.h conf_regparams.h conf_sal.h conf_spi.h conf_hw_timer.h conf_pmm.h
  group thirdparty/wireless/ble_sdk/apps/pxp_monitor/samr34_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/ble_sdk/apps/config/samr34
    ../../../config/samr34/: conf_clocks.h conf_serialdrv.h conf_board.h conf_extint.h conf_timer.h conf_console.h
  group thirdparty/wireless/ble_sdk/ble_profiles/pxp_monitor
    ../../../../ble_profiles/pxp_monitor/: pxp_monitor.c pxp_monitor.h
  group thirdparty/wireless/ble_sdk/inc
    ../../../../inc/: at_ble_trace.h platform.h at_ble_errno.h at_ble_api.h profiles.h
  group thirdparty/wireless/ble_sdk/utils
    ../../../../utils/: ble_utils.h
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0
    ../../../../../services/common_hw_timer/sam0/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0/lib
    ../../../../../services/common_hw_timer/sam0/lib/: sam0_lib_hw_timer.a
  group thirdparty/wireless/services/nvm
    ../../../../../services/nvm/: common_nvm.h
  group thirdparty/wireless/services/nvm/sam0
    ../../../../../services/nvm/sam0/: sam_nvm.c
  group thirdparty/wireless/lorawan/services/pds/src
    ../../../../../lorawan/services/pds/src/: pds_task_handler.c pds_interface.c pds_nvm.c pds_wl.c
  group thirdparty/wireless/lorawan/services/pds/inc
    ../../../../../lorawan/services/pds/inc/: pds_wl.h pds_common.h pds_nvm.h pds_interface.h pds_task_handler.h
  group thirdparty/wireless/lorawan/services/sw_timer/src
    ../../../../../lorawan/services/sw_timer/src/: sw_timer.c
  group thirdparty/wireless/lorawan/services/sw_timer/inc
    ../../../../../lorawan/services/sw_timer/inc/: sw_timer.h
  group thirdparty/wireless/lorawan/services/aes/src/hw/sam0
    ../../../../../lorawan/services/aes/src/hw/sam0/: aes_engine.c
  group thirdparty/wireless/lorawan/services/aes/inc
    ../../../../../lorawan/services/aes/inc/: aes_def.h aes_engine.h
  group thirdparty/wireless/lorawan/hal/src
    ../../../../../lorawan/hal/src/: sys.c radio_driver_hal.c
  group thirdparty/wireless/lorawan/hal/src/sleep/sam0
    ../../../../../lorawan/hal/src/sleep/sam0/: sleep.c
  group thirdparty/wireless/lorawan/hal/src/sleep_timer/sam0
    ../../../../../lorawan/hal/src/sleep_timer/sam0/: sleep_timer.c
  group thirdparty/wireless/lorawan/hal/inc
    ../../../../../lorawan/hal/inc/: radio_driver_hal.h sleep_timer.h sleep.h atomic.h sys.h
  group thirdparty/wireless/lorawan/sys/src
    ../../../../../lorawan/sys/src/: system_assert.c system_task_manager.c system_init.c system_low_power.c
  group thirdparty/wireless/lorawan/sys/inc
    ../../../../../lorawan/sys/inc/: system_low_power.h system_assert.h system_task_manager.h system_init.h
  group thirdparty/wireless/lorawan/regparams/multiband/src
    ../../../../../lorawan/regparams/multiband/src/: lorawan_mband_kr.c lorawan_mband_eu.c lorawan_multiband.c lorawan_mband_jp.c lorawan_mband_in.c lorawan_mband_as.c lorawan_mband_au.c lorawan_mband_na.c
  group thirdparty/wireless/lorawan/regparams/multiband/inc
    ../../../../../lorawan/regparams/multiband/inc/: lorawan_multiband.h
  group thirdparty/wireless/lorawan/regparams/inc
    ../../../../../lorawan/regparams/inc/: lorawan_reg_params.h
  group thirdparty/wireless/lorawan/tal/sx1276/src
    ../../../../../lorawan/tal/sx1276/src/: radio_driver_SX1276.c
  group thirdparty/wireless/lorawan/tal/sx1276/inc
    ../../../../../lorawan/tal/sx1276/inc/: radio_registers_SX1276.h radio_driver_SX1276.h
  group thirdparty/wireless/lorawan/tal/inc
    ../../../../../lorawan/tal/inc/: radio_lbt.h radio_task_manager.h radio_interface.h radio_get_set.h radio_transaction.h
  group thirdparty/wireless/lorawan/sal/src
    ../../../../../lorawan/sal/src/: sal.c
  group thirdparty/wireless/lorawan/sal/inc
    ../../../../../lorawan/sal/inc/: sal.h
  group thirdparty/wireless/lorawan/pmm/src
    ../../../../../lorawan/pmm/src/: pmm.c
  group thirdparty/wireless/lorawan/pmm/inc
    ../../../../../lorawan/pmm/inc/: pmm.h
  group thirdparty/wireless/lorawan/inc
    ../../../../../lorawan/inc/: stack_common.h conf_stack.h
  group thirdparty/wireless/lorawan/mac/inc
    ../../../../../lorawan/mac/inc/: lorawan.h
  group sam0/drivers/nvm
    ../../../../../../../sam0/drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../sam0/drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/drivers/tc
    ../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../../../../sam0/drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/rtc
    ../../../../../../../sam0/drivers/rtc/: rtc_tamper.h rtc_count_interrupt.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../../../../../sam0/drivers/rtc/rtc_sam_l_c/: rtc_count_interrupt.c rtc_count.c
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr34
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr34/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samr34
    ../../../../../../../sam0/drivers/system/clock/clock_samr34/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/extint
    ../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/spi
    ../../../../../../../sam0/drivers/sercom/spi/: spi.c spi_interrupt.c spi.h spi_interrupt.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/aes
    ../../../../../../../sam0/drivers/aes/: aes_callback.c aes.c aes.h aes_callback.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr34/source
    ../../../../../../../sam0/utils/cmsis/samr34/source/: system_samr34.c system_samr34.h
  group sam0/utils/cmsis/samr34/source/iar
    ../../../../../../../sam0/utils/cmsis/samr34/source/iar/: startup_samr34.c
  group sam0/utils/cmsis/samr34/include
    ../../../../../../../sam0/utils/cmsis/samr34/include/: samr34j17b.h samr34j18b.h samr34j16b.h samr34.h
  group sam0/utils/cmsis/samr34/include/instance
    ../../../../../../../sam0/utils/cmsis/samr34/include/instance/: tc3.h dmac.h sercom3.h wdt.h port.h sercom1.h evsys.h rtc.h dac.h osc32kctrl.h pac.h mclk.h mtb.h adc.h tcc2.h sercom4.h pm.h sercom5.h ac.h tcc1.h ccl.h dsu.h usb.h eic.h tal.h tc0.h oscctrl.h nvmctrl.h supc.h rstc.h tcc0.h tc2.h gclk.h sercom2.h trng.h tc4.h sercom0.h tc1.h aes.h
  group sam0/utils/cmsis/samr34/include/component
    ../../../../../../../sam0/utils/cmsis/samr34/include/component/: nvmctrl.h sercom.h dmac.h rtc.h pac.h trng.h evsys.h tal.h eic.h osc32kctrl.h dsu.h supc.h port.h oscctrl.h usb.h pm.h ac.h mclk.h tcc.h gclk.h rstc.h adc.h mtb.h ccl.h aes.h dac.h wdt.h tc.h
  group sam0/utils/cmsis/samr34/include/pio
    ../../../../../../../sam0/utils/cmsis/samr34/include/pio/: samr34j18b.h samr34j16b.h samr34j17b.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: tpaste.h mrepeat.h mrecursion.h stringz.h preprocessor.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samr34_xplained_pro
    ../../../../../../../sam0/boards/samr34_xplained_pro/: board_init.c samr34_xplained_pro.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
