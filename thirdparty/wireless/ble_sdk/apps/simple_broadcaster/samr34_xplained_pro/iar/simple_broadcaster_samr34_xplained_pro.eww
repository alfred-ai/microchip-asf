<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\simple_broadcaster_samr34_xplained_pro_flash.ewp</path>
	</project>
</workspace>
