# IAR project freertos_peripheral_control_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __FREERTOS__; ARM_MATH_CM3=true; UDD_ENABLE; BOARD=SAM3S_EK2; __SAM3SD8C__
  ICCARM.CCIncludePath2: ../../../../../../common/services/usb/class/cdc/device; ../../../../../../sam/utils/header_files; ../../../../../../sam/drivers/udp; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../freertos-7.3.0/source/portable/iar/sam; ../../../../../../common/services/serial; ../../../../../../common/services/clock; ../../../../../../sam/utils/cmsis/sam3s8/source/templates; ..; ../../../../../../sam/boards; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/usb/class/cdc; ../../../../../../common/services/freertos/sam; ../../../../freertos-7.3.0/source/include; ../../../../../../sam/drivers/matrix; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../sam/drivers/pdc; ../../../../../../common/services/usb; ../../demo-tasks; ../../../../../../sam/boards/sam3s_ek2; ../../../../../../common/services/gpio; ../..; ../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../common/services/usb/udc; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pio; ../../../../../../sam/utils/cmsis/sam3s8/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_peripheral_control_flash.bin
  ILINK.IlinkOutputFile: freertos_peripheral_control_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc.h udi_cdc_conf.h
  group common/services/usb/udc
    ../../../../../../common/services/usb/udc/: udc.c udc.h udd.h udi.h udc_desc.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/freertos/sam
    ../../../../../../common/services/freertos/sam/: freertos_peripheral_control.c freertos_uart_serial.c freertos_usart_serial.c freertos_peripheral_control.h freertos_peripheral_control_private.h freertos_uart_serial.h freertos_usart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/udp
    ../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/matrix
    ../../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/boards/sam3s_ek2
    ../../../../../../sam/boards/sam3s_ek2/: led.c init.c sam3s_ek2.h led.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../../sam/utils/cmsis/sam3s8/source/templates/: system_sam3sd8.c exceptions.c system_sam3sd8.h exceptions.h
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/cmsis/sam3s8/include
    ../../../../../../sam/utils/cmsis/sam3s8/include/: sam3sd8b.h sam3s8b.h sam3sd8c.h sam3s8c.h sam3s8.h
  group sam/utils/cmsis/sam3s8/include/component
    ../../../../../../sam/utils/cmsis/sam3s8/include/component/: component_supc.h component_ssc.h component_rtt.h component_gpbr.h component_adc.h component_twi.h component_pmc.h component_chipid.h component_smc.h component_pwm.h component_crccu.h component_rtc.h component_acc.h component_pio.h component_hsmci.h component_pdc.h component_rstc.h component_efc.h component_wdt.h component_dacc.h component_tc.h component_usart.h component_matrix.h component_udp.h component_spi.h component_uart.h
  group sam/utils/cmsis/sam3s8/include/instance
    ../../../../../../sam/utils/cmsis/sam3s8/include/instance/: instance_piob.h instance_wdt.h instance_rstc.h instance_supc.h instance_matrix.h instance_efc.h instance_adc.h instance_uart0.h instance_ssc.h instance_hsmci.h instance_gpbr.h instance_uart1.h instance_acc.h instance_twi0.h instance_twi1.h instance_chipid.h instance_smc.h instance_tc0.h instance_usart2.h instance_udp.h instance_pwm.h instance_rtc.h instance_pmc.h instance_pioc.h instance_rtt.h instance_pioa.h instance_tc1.h instance_usart1.h instance_spi.h instance_dacc.h instance_usart0.h instance_crccu.h
  group sam/utils/cmsis/sam3s8/include/pio
    ../../../../../../sam/utils/cmsis/sam3s8/include/pio/: pio_sam3sd8b.h pio_sam3s8b.h pio_sam3sd8c.h pio_sam3s8c.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../freertos-7.3.0/source/: queue.c timers.c tasks.c list.c FreeRTOS_CLI.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../freertos-7.3.0/source/include/: croutine.h queue.h mpu_wrappers.h FreeRTOS_CLI.h semphr.h task.h FreeRTOS.h list.h StackMacros.h portable.h timers.h projdefs.h
  group thirdparty/freertos/demo/peripheral_control
    ../../: partest.c run-time-stats-utils.c main.c demo-tasks.h FreeRTOSConfig.h partest.h
  group thirdparty/freertos/demo/peripheral_control/demo-tasks
    ../../demo-tasks/: USART-echo-tasks.c USB-CDC-CLI-task.c UART-CLI-task.c CLI-commands.c USART-CLI-task.c
  group thirdparty/freertos/demo/peripheral_control/sam3sd8c_sam3s_ek2
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_usb.h conf_sleepmgr.h conf_example.h
  group thirdparty/freertos/demo/peripheral_control/sam3sd8c_sam3s_ek2/iar
    ./: asf.h
