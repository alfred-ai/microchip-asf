# IAR project freertos_sam_lwip_dhcp_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: HTTP_USED=1; FREERTOS_USED; TFTP_USED=1; ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__; __FREERTOS__
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/header_files; ../../../../../../sam/drivers/rstc; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/components/ethernet_phy/dm9161a; ../../../../../../sam/drivers/pmc; ../../../../../../sam/boards/sam3x_ek; ../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../lwip_avr32_uc3_example/network/basictftp; ../../../../../lwip/lwip-1.4.0/src/include; ../../../../../../common/services/serial; ../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../common/utils; ../../../../../../sam/drivers/emac; ../..; ../../../../freertos-7.0.0/source/portable/iar/sam; ../../../common/include; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../lwip/lwip-1.4.0/src/include/lwip; ../../network; ../../../../../../common/services/gpio; ../../../../../../sam/drivers/uart; ../../../../freertos-7.0.0/source/include; ../../../../../../sam/utils; ../../../lwip_avr32_uc3_example/network/basicweb; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../lwip/lwip-port-1.4.0/sam/include; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pio; ..; ../../../../../../sam/drivers/tc; ../../../../../lwip/lwip-1.4.0/src/include/ipv4; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_lwip_dhcp_example_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_lwip_dhcp_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x8000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.0/src/core
    ../../../../../lwip/lwip-1.4.0/src/core/: tcp_in.c stats.c pbuf.c lwip_timers_140.c dhcp.c def.c sys.c tcp_out.c mem.c memp.c dns.c init.c tcp.c raw.c udp.c netif.c
  group thirdparty/lwip/lwip-1.4.0/src/core/ipv4
    ../../../../../lwip/lwip-1.4.0/src/core/ipv4/: inet_chksum.c autoip.c ip_addr.c ip_frag.c igmp.c ip.c inet.c icmp.c
  group thirdparty/lwip/lwip-1.4.0/src/netif
    ../../../../../lwip/lwip-1.4.0/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.0/src/api
    ../../../../../lwip/lwip-1.4.0/src/api/: netbuf.c netdb.c sockets.c api_msg.c err.c tcpip.c api_lib.c netifapi.c
  group thirdparty/lwip/lwip-1.4.0/src/include/lwip
    ../../../../../lwip/lwip-1.4.0/src/include/lwip/: api.h udp.h sockets.h pbuf.h timers.h raw.h memp_std.h tcp_impl.h def.h snmp_structs.h debug.h memp.h err.h sys.h dhcp.h dns.h opt.h sio.h mem.h arch.h snmp_asn1.h tcpip.h init.h netifapi.h netdb.h netif.h snmp.h api_msg.h netbuf.h tcp.h snmp_msg.h stats.h
  group thirdparty/lwip/lwip-1.4.0/src/include/ipv4/lwip
    ../../../../../lwip/lwip-1.4.0/src/include/ipv4/lwip/: igmp.h icmp.h autoip.h ip_frag.h ip_addr.h inet_chksum.h ip.h inet.h
  group thirdparty/lwip/lwip-1.4.0/src/include/netif
    ../../../../../lwip/lwip-1.4.0/src/include/netif/: etharp.h ppp_oe.h
  group thirdparty/lwip/lwip-port-1.4.0/sam
    ../../../../../lwip/lwip-port-1.4.0/sam/: sys_arch.c
  group thirdparty/lwip/lwip-port-1.4.0/sam/netif
    ../../../../../lwip/lwip-port-1.4.0/sam/netif/: ethernetif.c
  group thirdparty/lwip/lwip-port-1.4.0/sam/include/netif
    ../../../../../lwip/lwip-port-1.4.0/sam/include/netif/: ethernetif.h
  group thirdparty/lwip/lwip-port-1.4.0/sam/include/arch
    ../../../../../lwip/lwip-port-1.4.0/sam/include/arch/: perf.h cc.h sys_arch.h
  group thirdparty/freertos/demo/lwip_sam_example
    ../../: main.c FreeRTOSConfig.h lwipopts.h
  group thirdparty/freertos/demo/lwip_sam_example/partest
    ../../partest/: ParTest.c
  group thirdparty/freertos/demo/lwip_sam_example/network
    ../../network/: ethernet.c ethernet.h
  group thirdparty/freertos/demo/lwip_sam_example/sam3x8h_sam3x_ek
    ../: conf_uart_serial.h conf_board.h conf_clock.h conf_eth.h conf_lwip_threads.h
  group thirdparty/freertos/demo/lwip_sam_example/sam3x8h_sam3x_ek/iar
    ./: asf.h
  group thirdparty/freertos/demo/common/minimal
    ../../../common/minimal/: flash.c
  group thirdparty/freertos/demo/common/include
    ../../../common/include/: partest.h flash.h
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basictftp
    ../../../lwip_avr32_uc3_example/network/basictftp/: BasicTFTP.c BasicTFTP.h
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basicweb
    ../../../lwip_avr32_uc3_example/network/basicweb/: BasicWEB.c BasicWEB.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../freertos-7.0.0/source/: timers.c queue.c list.c croutine.c tasks.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam
    ../../../../freertos-7.0.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../freertos-7.0.0/source/include/: semphr.h list.h FreeRTOS.h projdefs.h mpu_wrappers.h task.h queue.h croutine.h timers.h StackMacros.h portable.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam3x
    ../../../../../../common/services/clock/sam3x/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/components/ethernet_phy
    ../../../../../../sam/components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/dm9161a
    ../../../../../../sam/components/ethernet_phy/dm9161a/: ethernet_phy.c ethernet_phy.h mii.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/rstc/example1
    ../../../../../../sam/drivers/rstc/example1/: rstc_example1.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/emac
    ../../../../../../sam/drivers/emac/: emac.c emac.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/boards/sam3x_ek
    ../../../../../../sam/boards/sam3x_ek/: led.c led.h sam3x_ek.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c exceptions.h system_sam3x.h
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/sam3x/include
    ../../../../../../sam/utils/cmsis/sam3x/include/: sam3x8h.h sam3a4c.h sam3x8c.h sam3a8c.h sam3x8e.h sam3x4e.h sam3x4c.h sam3xa.h
  group sam/utils/cmsis/sam3x/include/instance
    ../../../../../../sam/utils/cmsis/sam3x/include/instance/: instance_piof.h instance_tc0.h instance_rstc.h instance_smc.h instance_supc.h instance_adc.h instance_sdramc.h instance_wdt.h instance_ssc.h instance_dacc.h instance_piod.h instance_efc1.h instance_uotghs.h instance_pioa.h instance_usart1.h instance_matrix.h instance_usart3.h instance_hsmci.h instance_gpbr.h instance_pioc.h instance_trng.h instance_efc0.h instance_emac.h instance_chipid.h instance_usart0.h instance_twi0.h instance_spi1.h instance_pwm.h instance_rtc.h instance_usart2.h instance_twi1.h instance_uart.h instance_can0.h instance_tc2.h instance_spi0.h instance_tc1.h instance_rtt.h instance_pmc.h instance_piob.h instance_dmac.h instance_can1.h instance_pioe.h
  group sam/utils/cmsis/sam3x/include/component
    ../../../../../../sam/utils/cmsis/sam3x/include/component/: component_ssc.h component_dmac.h component_gpbr.h component_rstc.h component_emac.h component_sdramc.h component_pmc.h component_usart.h component_dacc.h component_pwm.h component_hsmci.h component_pdc.h component_efc.h component_adc.h component_matrix.h component_pio.h component_uotghs.h component_can.h component_wdt.h component_uart.h component_rtt.h component_twi.h component_trng.h component_tc.h component_chipid.h component_rtc.h component_smc.h component_spi.h component_supc.h
  group sam/utils/cmsis/sam3x/include/pio
    ../../../../../../sam/utils/cmsis/sam3x/include/pio/: pio_sam3a8c.h pio_sam3a4c.h pio_sam3x4c.h pio_sam3x8e.h pio_sam3x8c.h pio_sam3x4e.h pio_sam3x8h.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
