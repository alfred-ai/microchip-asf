# IAR project freertos_sam_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel ATSAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __FREERTOS__; __SAMV71Q21B__; BOARD=SAMV71_XPLAINED_ULTRA; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../../../sam/utils/fpu; ../../../../freertos-8.2.3/Source/include; ../../../../../../sam/drivers/mpu; ../../../../../../common/utils; ../..; ../../../../../../sam/utils/cmsis/samv71/source/templates; ..; ../../../../../../sam/boards/samv71_xplained_ultra; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../../common/services/serial/sam_uart; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pio; ../../../../freertos-8.2.3/Source/portable/IAR/ARM_CM7/r0p1; ../../../../../../sam/utils/cmsis/samv71/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_example_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/samv71/samv71q21/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1800
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/samv71
    ../../../../../../common/services/clock/samv71/: sysclk.c sysclk.h osc.h genclk.h pll.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/freertos/freertos-8.2.3/Source
    ../../../../freertos-8.2.3/Source/: queue.c croutine.c list.c event_groups.c tasks.c timers.c
  group thirdparty/freertos/freertos-8.2.3/Source/portable/MemMang
    ../../../../freertos-8.2.3/Source/portable/MemMang/: heap_3.c
  group thirdparty/freertos/freertos-8.2.3/Source/portable/IAR/ARM_CM7/r0p1
    ../../../../freertos-8.2.3/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-8.2.3/Source/include
    ../../../../freertos-8.2.3/Source/include/: deprecated_definitions.h mpu_wrappers.h FreeRTOS.h task.h list.h queue.h StackMacros.h timers.h portable.h croutine.h event_groups.h projdefs.h semphr.h
  group thirdparty/freertos/demo/sam_example
    ../../: main.c
  group thirdparty/freertos/demo/sam_example/samv71q21_samv71_xplained_ultra
    ../: conf_uart_serial.h conf_clock.h conf_board.h FreeRTOSConfig.h
  group thirdparty/freertos/demo/sam_example/samv71q21_samv71_xplained_ultra/iar
    ./: asf.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/mpu
    ../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/boards/samv71_xplained_ultra
    ../../../../../../sam/boards/samv71_xplained_ultra/: init.c samv71_xplained_ultra.h led.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/samv71/source/templates
    ../../../../../../sam/utils/cmsis/samv71/source/templates/: system_samv71.c system_samv71.h
  group sam/utils/cmsis/samv71/source/templates/iar
    ../../../../../../sam/utils/cmsis/samv71/source/templates/iar/: startup_samv71.c
  group sam/utils/cmsis/samv71/include
    ../../../../../../sam/utils/cmsis/samv71/include/: samv71n20.h samv71q20b.h samv71j21b.h samv71j21.h samv71.h samv71n21.h samv71n19b.h samv71q19.h samv71j20b.h samv71q21.h samv71j19b.h samv71q21b.h samv71q19b.h samv71n20b.h samv71j20.h samv71n21b.h samv71q20.h samv71j19.h samv71n19.h
  group sam/utils/cmsis/samv71/include/component
    ../../../../../../sam/utils/cmsis/samv71/include/component/: tc.h hsmci.h uart.h rtt.h acc.h aes.h rstc.h qspi.h usart.h pio.h supc.h matrix.h ssc.h wdt.h spi.h twihs.h pwm.h icm.h rswdt.h usbhs.h gpbr.h pmc.h isi.h afec.h i2sc.h trng.h utmi.h dacc.h sdramc.h gmac.h efc.h rtc.h smc.h chipid.h mlb.h mcan.h xdmac.h
  group sam/utils/cmsis/samv71/include/instance
    ../../../../../../sam/utils/cmsis/samv71/include/instance/: mcan1.h pwm1.h i2sc0.h usart2.h uart0.h gmac.h tc1.h uart2.h tc3.h rswdt.h supc.h icm.h isi.h pwm0.h pioe.h chipid.h rtt.h trng.h afec0.h efc.h usart0.h afec1.h pioa.h smc.h piod.h spi1.h ssc.h dacc.h mlb.h twihs2.h pmc.h wdt.h aes.h pioc.h twihs0.h acc.h hsmci.h usart1.h piob.h utmi.h xdmac.h sdramc.h mcan0.h spi0.h matrix.h usbhs.h twihs1.h rtc.h uart4.h uart1.h tc0.h rstc.h qspi.h tc2.h uart3.h i2sc1.h gpbr.h
  group sam/utils/cmsis/samv71/include/pio
    ../../../../../../sam/utils/cmsis/samv71/include/pio/: samv71n21b.h samv71n19.h samv71n19b.h samv71n20b.h samv71j21b.h samv71q19b.h samv71n20.h samv71q20.h samv71n21.h samv71j19b.h samv71j19.h samv71q21.h samv71q20b.h samv71q21b.h samv71j20.h samv71j20b.h samv71j21.h samv71q19.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
