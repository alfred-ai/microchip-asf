# IAR project thirdparty_lwip_raw_basic_http_example_ajax_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAMR21_XPLAINED_PRO; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; __SAMR21G18A__; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../sam0/drivers/port; ../../../lwip-1.4.1/src/include/ipv4; ../../../../../sam0/drivers/system/reset; ../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21; ../../../lwip-1.4.1/src/include/lwip; ../../../../../sam0/utils/preprocessor; ../../../../../sam0/utils/cmsis/samr21/source; ../../../../../common2/services/delay; ../../../../../sam0/drivers/sercom/spi; ../../../lwip-1.4.1/src/include; ../../../../../sam0/utils; ../../../../../sam0/drivers/sercom; ../../../../../sam0/drivers/system/power; ../../../../../sam0/boards; ../../../lwip-port-1.4.1/sam/include/netif; ../../../../../sam0/drivers/sercom/usart; ../../../../../common/services/serial; ../../../../../common/utils; ../../../../../sam0/drivers/system/clock; ../../../../../sam0/drivers/extint/extint_sam_d_r; ../../../../../sam0/drivers/system/interrupt; ../../network; ../../../../../sam0/drivers/system/power/power_sam_d_r; ../../../../../sam0/drivers/tc; ../../../../../sam0/drivers/system/reset/reset_sam_d_r; ..; ../../network/httpserver; ../../../../../common2/services/delay/sam0; ../../../../../sam0/boards/samr21_xplained_pro; ../../../../../sam0/utils/cmsis/samr21/include; ../../../../../sam0/drivers/system/pinmux; ../..; ../../../../../common/boards; ../../../../../sam0/components/ethernet_phy/ksz8851snl; ../../../../../sam0/drivers/system; ../../../lwip-port-1.4.1/sam/include; ../../../../../sam0/drivers/extint; ../../../../../sam0/utils/header_files; ../../../../../sam0/drivers/system/clock/clock_samd21_r21_da; ../../../../../sam0/utils/stdio/stdio_serial; ../../../../../sam0/drivers/tc/tc_sam_d_r; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thirdparty_lwip_raw_basic_http_example_ajax_flash.bin
  ILINK.IlinkOutputFile: thirdparty_lwip_raw_basic_http_example_ajax_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam0/utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0; --config_def __ICFEDIT_size_cstack__=0xa00
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.1/src/api
    ../../../lwip-1.4.1/src/api/: sockets.c api_lib.c netbuf.c api_msg.c tcpip.c err.c netifapi.c netdb.c
  group thirdparty/lwip/lwip-1.4.1/src/core
    ../../../lwip-1.4.1/src/core/: tcp_in.c mem.c stats.c dhcp.c lwip_init.c tcp_out.c dns.c sys.c raw.c pbuf.c def.c netif.c udp.c tcp.c lwip_timers_141.c memp.c
  group thirdparty/lwip/lwip-1.4.1/src/core/ipv4
    ../../../lwip-1.4.1/src/core/ipv4/: inet_chksum.c icmp.c igmp.c ip_frag.c autoip.c inet.c ip_addr.c ip.c
  group thirdparty/lwip/lwip-1.4.1/src/netif
    ../../../lwip-1.4.1/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.1/src/include/lwip
    ../../../lwip-1.4.1/src/include/lwip/: stats.h def.h snmp_msg.h err.h netdb.h snmp.h netifapi.h netbuf.h sockets.h netif.h api.h timers.h udp.h mem.h raw.h opt.h debug.h pbuf.h sio.h memp.h arch.h snmp_asn1.h init.h api_msg.h snmp_structs.h dns.h tcp.h dhcp.h tcpip.h memp_std.h sys.h tcp_impl.h
  group thirdparty/lwip/lwip-1.4.1/src/include/ipv4/lwip
    ../../../lwip-1.4.1/src/include/ipv4/lwip/: ip_frag.h inet.h ip.h igmp.h icmp.h autoip.h ip_addr.h inet_chksum.h
  group thirdparty/lwip/lwip-1.4.1/src/include/netif
    ../../../lwip-1.4.1/src/include/netif/: ppp_oe.h etharp.h
  group thirdparty/lwip/raw_http_basic_example_ajax
    ../../: main.c
  group thirdparty/lwip/raw_http_basic_example_ajax/network
    ../../network/: ethernet.c timer_mgt.c ethernet.h timer_mgt.h
  group thirdparty/lwip/raw_http_basic_example_ajax/network/httpserver
    ../../network/httpserver/: fsdata.c httpd.c fs.c fsdata.h httpd.h fs.h
  group thirdparty/lwip/raw_http_basic_example_ajax/samr21_xplained_pro
    ../: conf_eth.h conf_timer.h conf_spi.h conf_board.h lwipopts.h conf_clocks.h conf_extint.h
  group thirdparty/lwip/raw_http_basic_example_ajax/samr21_xplained_pro/iar
    ./: asf.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/netif
    ../../../lwip-port-1.4.1/sam/netif/: sam0_spi_ksz8851snl.c
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/netif
    ../../../lwip-port-1.4.1/sam/include/netif/: sam0_spi_ksz8851snl.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/arch
    ../../../lwip-port-1.4.1/sam/include/arch/: perf.h cc.h
  group sam0/drivers/tc
    ../../../../../sam0/drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_d_r
    ../../../../../sam0/drivers/tc/tc_sam_d_r/: tc.c
  group sam0/drivers/system
    ../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da
    ../../../../../sam0/drivers/system/clock/clock_samd21_r21_da/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../../sam0/drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../../sam0/drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/extint
    ../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_d_r
    ../../../../../sam0/drivers/extint/extint_sam_d_r/: extint.c
  group sam0/drivers/sercom
    ../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom.h sercom_interrupt.h sercom_pinout.h
  group sam0/drivers/sercom/spi
    ../../../../../sam0/drivers/sercom/spi/: spi.c spi_interrupt.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/usart
    ../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/port
    ../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/stdio
    ../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../sam0/utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../sam0/utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../sam0/utils/cmsis/samr21/include/: samr21e16a.h samr21.h samr21e17a.h samr21g18a.h samr21e18a.h samr21g17a.h samr21g16a.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../sam0/utils/cmsis/samr21/include/instance/: sercom3.h sercom5.h gclk.h sercom1.h ac.h adc.h mtb.h evsys.h port.h sbmatrix.h tcc1.h rfctrl.h usb.h pm.h tc4.h nvmctrl.h tcc2.h tcc0.h pac1.h sysctrl.h eic.h dsu.h wdt.h sercom2.h dmac.h sercom4.h pac2.h tc5.h sercom0.h tc3.h rtc.h pac0.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../sam0/utils/cmsis/samr21/include/pio/: samr21e16a.h samr21e18a.h samr21g17a.h samr21e17a.h samr21g16a.h samr21g18a.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../sam0/utils/cmsis/samr21/include/component/: tc.h gclk.h nvmctrl.h usb.h wdt.h rfctrl.h dmac.h sercom.h rtc.h pm.h ac.h hmatrixb.h mtb.h dsu.h adc.h port.h sysctrl.h evsys.h eic.h pac.h tcc.h
  group sam0/utils/preprocessor
    ../../../../../sam0/utils/preprocessor/: preprocessor.h tpaste.h mrepeat.h mrecursion.h stringz.h
  group sam0/utils/header_files
    ../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../sam0/boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group sam0/components/ethernet_phy/ksz8851snl
    ../../../../../sam0/components/ethernet_phy/ksz8851snl/: ksz8851snl.c ksz8851snl.h ksz8851snl_reg.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
