# IAR project thirdparty_lwip_raw_basic_http_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel ATSAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMV71Q21B__; BOARD=SAMV71_XPLAINED_ULTRA; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ../..; ../../network/httpserver; ../../../../../sam/utils/header_files; ../../../lwip-1.4.1/src/include/ipv4; ../../../lwip-1.4.1/src/include/lwip; ../../../../../sam/utils/preprocessor; ../../../../../sam/drivers/pio; ../../network; ../../../lwip-1.4.1/src/include; ../../../lwip-port-1.4.1/sam/include/netif; ../../../../../sam/utils/fpu; ../../../../../common/services/serial; ../../../../../sam/utils/cmsis/samv71/source/templates; ../../../../../sam/drivers/mpu; ../../../../../common/utils; ../../../../../sam/drivers/gmac; ../../../../../sam/boards/samv71_xplained_ultra; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ..; ../../../../../common/services/gpio; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../sam/drivers/usart; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../../sam/drivers/pmc; ../../../lwip-port-1.4.1/sam/include; ../../../../../sam/components/ethernet_phy/ksz8061rnb; ../../../../../sam/utils/cmsis/samv71/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thirdparty_lwip_raw_basic_http_example_flash.bin
  ILINK.IlinkOutputFile: thirdparty_lwip_raw_basic_http_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/samv71/samv71q21/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0; --config_def __ICFEDIT_size_cstack__=0x400
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.1/src/api
    ../../../lwip-1.4.1/src/api/: sockets.c api_lib.c api_msg.c netdb.c tcpip.c err.c netbuf.c netifapi.c
  group thirdparty/lwip/lwip-1.4.1/src/core
    ../../../lwip-1.4.1/src/core/: tcp_in.c mem.c stats.c dhcp.c lwip_init.c tcp.c dns.c sys.c raw.c pbuf.c udp.c def.c netif.c tcp_out.c lwip_timers_141.c memp.c
  group thirdparty/lwip/lwip-1.4.1/src/core/ipv4
    ../../../lwip-1.4.1/src/core/ipv4/: inet_chksum.c autoip.c igmp.c ip_frag.c icmp.c inet.c ip_addr.c ip.c
  group thirdparty/lwip/lwip-1.4.1/src/netif
    ../../../lwip-1.4.1/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.1/src/include/lwip
    ../../../lwip-1.4.1/src/include/lwip/: stats.h def.h snmp_msg.h err.h netdb.h snmp.h netifapi.h netbuf.h sockets.h netif.h api.h dns.h timers.h udp.h mem.h raw.h opt.h debug.h pbuf.h sio.h memp.h arch.h init.h snmp_asn1.h api_msg.h snmp_structs.h sys.h tcp.h dhcp.h tcpip.h memp_std.h tcp_impl.h
  group thirdparty/lwip/lwip-1.4.1/src/include/ipv4/lwip
    ../../../lwip-1.4.1/src/include/ipv4/lwip/: inet.h ip_frag.h ip.h inet_chksum.h igmp.h autoip.h ip_addr.h icmp.h
  group thirdparty/lwip/lwip-1.4.1/src/include/netif
    ../../../lwip-1.4.1/src/include/netif/: etharp.h ppp_oe.h
  group thirdparty/lwip/raw_http_basic_example
    ../../: raw_http_basic_example.c
  group thirdparty/lwip/raw_http_basic_example/network
    ../../network/: ethernet.c timer_mgt.c ethernet.h timer_mgt.h
  group thirdparty/lwip/raw_http_basic_example/network/httpserver
    ../../network/httpserver/: fsdata.c httpd.c fs.c fsdata.h httpd.h fs.h
  group thirdparty/lwip/raw_http_basic_example/samv71q21_samv71_xplained_ultra
    ../: conf_uart_serial.h conf_board.h conf_eth.h lwipopts.h conf_clock.h
  group thirdparty/lwip/raw_http_basic_example/samv71q21_samv71_xplained_ultra/iar
    ./: asf.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/netif
    ../../../lwip-port-1.4.1/sam/netif/: samv71_gmac.c
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/netif
    ../../../lwip-port-1.4.1/sam/include/netif/: samv71_gmac.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/arch
    ../../../lwip-port-1.4.1/sam/include/arch/: perf.h cc.h
  group sam/drivers/mpu
    ../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/gmac
    ../../../../../sam/drivers/gmac/: gmac_phy.c gmac.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samv71/source/templates
    ../../../../../sam/utils/cmsis/samv71/source/templates/: system_samv71.c system_samv71.h
  group sam/utils/cmsis/samv71/source/templates/iar
    ../../../../../sam/utils/cmsis/samv71/source/templates/iar/: startup_samv71.c
  group sam/utils/cmsis/samv71/include
    ../../../../../sam/utils/cmsis/samv71/include/: samv71q19b.h samv71n19b.h samv71j19.h samv71n20b.h samv71q19.h samv71q20.h samv71q21b.h samv71j20b.h samv71n19.h samv71j21.h samv71q21.h samv71n21.h samv71j21b.h samv71j19b.h samv71n20.h samv71.h samv71j20.h samv71q20b.h samv71n21b.h
  group sam/utils/cmsis/samv71/include/pio
    ../../../../../sam/utils/cmsis/samv71/include/pio/: samv71n19.h samv71n21b.h samv71q21.h samv71q20b.h samv71n19b.h samv71n20.h samv71q20.h samv71q21b.h samv71j20b.h samv71q19b.h samv71j20.h samv71n21.h samv71j19.h samv71j21b.h samv71n20b.h samv71j19b.h samv71q19.h samv71j21.h
  group sam/utils/cmsis/samv71/include/instance
    ../../../../../sam/utils/cmsis/samv71/include/instance/: mcan0.h i2sc1.h gpbr.h spi0.h efc.h piob.h pwm1.h rtc.h icm.h dacc.h aes.h matrix.h uart4.h mlb.h spi1.h ssc.h rstc.h pioc.h twihs1.h tc1.h tc0.h piod.h rtt.h chipid.h xdmac.h afec1.h i2sc0.h pmc.h tc3.h uart1.h wdt.h sdramc.h rswdt.h twihs0.h uart2.h trng.h pioe.h uart0.h usart1.h isi.h pioa.h smc.h twihs2.h afec0.h gmac.h usart2.h mcan1.h tc2.h utmi.h qspi.h usbhs.h uart3.h pwm0.h usart0.h hsmci.h supc.h acc.h
  group sam/utils/cmsis/samv71/include/component
    ../../../../../sam/utils/cmsis/samv71/include/component/: mcan.h rtt.h aes.h usbhs.h mlb.h gmac.h sdramc.h pwm.h acc.h isi.h pio.h efc.h tc.h i2sc.h usart.h rswdt.h uart.h xdmac.h pmc.h qspi.h twihs.h wdt.h afec.h hsmci.h icm.h dacc.h utmi.h gpbr.h smc.h rstc.h ssc.h supc.h spi.h chipid.h rtc.h matrix.h trng.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../sam/utils/fpu/: fpu.h
  group sam/boards/samv71_xplained_ultra
    ../../../../../sam/boards/samv71_xplained_ultra/: init.c samv71_xplained_ultra.h led.h
  group sam/components/ethernet_phy
    ../../../../../sam/components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/ksz8061rnb
    ../../../../../sam/components/ethernet_phy/ksz8061rnb/: ethernet_phy.c ethernet_phy.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../common/services/clock/: genclk.h osc.h pll.h sysclk.h
  group common/services/clock/samv71
    ../../../../../common/services/clock/samv71/: sysclk.c sysclk.h genclk.h osc.h pll.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../common/boards/: board.h
