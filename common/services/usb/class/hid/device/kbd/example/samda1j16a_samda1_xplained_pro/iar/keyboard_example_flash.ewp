# IAR project keyboard_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMDA1J16A Atmel ATSAMDA1J16A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: UDD_ENABLE; EXTINT_CALLBACK_MODE=true; __SAMDA1J16A__; BOARD=SAMDA1_XPLAINED_PRO; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../../../sam0/utils; ../../../../../../../../../../sam0/drivers/port; ../../../../../../../../../../sam0/boards; ../../../../../../../../../../sam0/drivers/usb; ../../../../../../../../../../sam0/utils/cmsis/samda1/include; ../../..; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam0/drivers/extint/extint_sam_d_r; ../../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../../../sam0/drivers/system/power/power_sam_d_r; ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r; ../../../../..; ../../../../../../../../../../sam0/boards/samda1_xplained_pro; ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samda; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam0/drivers/usb/usb_sam_d_r; ../../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../..; ../..; ../../../../../../../../../../sam0/utils/cmsis/samda1/source; ../../../../../../../../../boards; ../../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../../sam0/drivers/system; ../../../../../../../../../../sam0/drivers/extint; ..; ../../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da; ../../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: keyboard_example_flash.bin
  ILINK.IlinkOutputFile: keyboard_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam0/utils/linker_scripts/samda1/iar/samda1j16a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/boards
    ../../../../../../../../../boards/: board.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../../../sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/kbd
    ../../../: udi_hid_kbd.c udi_hid_kbd.h udi_hid_kbd_conf.h udi_hid_kbd_desc.c
  group common/services/usb/class/hid/device/kbd/example
    ../../: conf_usb.h main.c main.h ui.h
  group common/services/usb/class/hid/device/kbd/example/samda1j16a_samda1_xplained_pro
    ../: conf_board.h conf_clocks.h conf_extint.h conf_sleepmgr.h ui.c
  group common/services/usb/class/hid/device/kbd/example/samda1j16a_samda1_xplained_pro/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udc.h udc_desc.h udd.h udi.h
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group sam0/boards/samda1_xplained_pro
    ../../../../../../../../../../sam0/boards/samda1_xplained_pro/: board_init.c samda1_xplained_pro.h
  group sam0/drivers/extint
    ../../../../../../../../../../sam0/drivers/extint/: extint.h extint_callback.c extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r
    ../../../../../../../../../../sam0/drivers/extint/extint_sam_d_r/: extint.c
  group sam0/drivers/port
    ../../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da
    ../../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da/: clock.c clock_config_check.h clock_feature.h gclk.c
  group sam0/drivers/system/interrupt
    ../../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samda
    ../../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samda/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../../../../../../../sam0/drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/usb
    ../../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_device_udd.c usb_dual.c usb_dual.h
  group sam0/drivers/usb/usb_sam_d_r
    ../../../../../../../../../../sam0/drivers/usb/usb_sam_d_r/: usb.c
  group sam0/utils
    ../../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samda1/include
    ../../../../../../../../../../sam0/utils/cmsis/samda1/include/: samda1.h samda1e14a.h samda1e15a.h samda1e16a.h samda1g14a.h samda1g15a.h samda1g16a.h samda1j14a.h samda1j15a.h samda1j16a.h
  group sam0/utils/cmsis/samda1/include/component
    ../../../../../../../../../../sam0/utils/cmsis/samda1/include/component/: ac.h adc.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h hmatrixb.h i2s.h mtb.h nvmctrl.h pac.h pm.h port.h rtc.h sercom.h sysctrl.h tc.h tcc.h usb.h wdt.h
  group sam0/utils/cmsis/samda1/include/instance
    ../../../../../../../../../../sam0/utils/cmsis/samda1/include/instance/: ac.h adc.h dac.h dmac.h dsu.h eic.h evsys.h gclk.h i2s.h mtb.h nvmctrl.h pac0.h pac1.h pac2.h pm.h port.h rtc.h sbmatrix.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h sysctrl.h tc3.h tc4.h tc5.h tc6.h tc7.h tcc0.h tcc1.h tcc2.h usb.h wdt.h
  group sam0/utils/cmsis/samda1/include/pio
    ../../../../../../../../../../sam0/utils/cmsis/samda1/include/pio/: samda1e14a.h samda1e15a.h samda1e16a.h samda1g14a.h samda1g15a.h samda1g16a.h samda1j14a.h samda1j15a.h samda1j16a.h
  group sam0/utils/cmsis/samda1/source
    ../../../../../../../../../../sam0/utils/cmsis/samda1/source/: system_samda1.c system_samda1.h
  group sam0/utils/cmsis/samda1/source/iar
    ../../../../../../../../../../sam0/utils/cmsis/samda1/source/iar/: startup_samda1.c
  group sam0/utils/header_files
    ../../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h mrepeat.h preprocessor.h stringz.h tpaste.h
