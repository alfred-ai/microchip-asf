# IAR project example_hids_cdc_msc_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAML21J18A__; USART_CALLBACK_MODE=true; ACCESS_USB_ENABLED; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; VIRTUAL_MEMORY_ENABLE; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../cdc/device; ../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../sam0/boards/saml21_xplained_pro; ../../../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../../../sam0/utils/preprocessor; ../../../../../msc; ../..; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/drivers/sercom; ../../../../../../../../../sam0/drivers/port; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../../../sam0/drivers/sercom/usart; ../../../../../hid/device/kbd; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../cdc; ../../../../../hid/device/mouse; ../../../../../msc/device; ../../../../../../../../../sam0/drivers/usb/usb_sam_l; ../../../../../../udc; ..; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ../../../../../../../../../sam0/drivers/extint/extint_sam_l_c; ../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../../sam0/boards; ../../../../../hid/device; ../../../../../../../../../sam0/utils/cmsis/saml21/include; ../../../../../../../../../sam0/drivers/system/clock/clock_saml21; ../../../../../../../../boards; ../../../../../..; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/usb; ../../../../../../../../../sam0/drivers/system; ../../../../../../../../../sam0/drivers/extint; ../../../../../hid; ../../../../../../../../../sam0/utils/cmsis/saml21/source; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../storage/ctrl_access; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_hids_cdc_msc_flash.bin
  ILINK.IlinkOutputFile: example_hids_cdc_msc_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_cstack__=0x0B00
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/saml
    ../../../../../../../sleepmgr/saml/: sleepmgr.c sleepmgr.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/composite/device
    ../../../: udi_composite_desc.c udi_composite_conf.h
  group common/services/usb/class/composite/device/example2
    ../../: uart_samd.c main.c memories_initialization_samd.c uart.h conf_usb.h ui.h main.h
  group common/services/usb/class/composite/device/example2/saml21j18a_saml21_xplained_pro
    ../: ui.c conf_virtual_mem.h conf_board.h conf_sleepmgr.h conf_example.h conf_access.h conf_clocks.h conf_extint.h
  group common/services/usb/class/composite/device/example2/saml21j18a_saml21_xplained_pro/iar
    ./: asf.h
  group common/services/usb/class/hid
    ../../../../../hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../../hid/device/: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../../../hid/device/mouse/: udi_hid_mouse.c udi_hid_mouse.h
  group common/services/usb/class/hid/device/kbd
    ../../../../../hid/device/kbd/: udi_hid_kbd.c udi_hid_kbd.h
  group common/services/usb/class/cdc
    ../../../../../cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../cdc/device/: udi_cdc.c udi_cdc.h
  group common/services/usb/class/msc
    ../../../../../msc/: usb_protocol_msc.h sbc_protocol.h spc_protocol.h
  group common/services/usb/class/msc/device
    ../../../../../msc/device/: udi_msc.c udi_msc.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udd.h udc_desc.h udc.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../../../sam0/drivers/system/clock/clock_saml21/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/extint
    ../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/usb
    ../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_device_udd.c usb_dual.c usb_dual.h
  group sam0/drivers/usb/usb_sam_l
    ../../../../../../../../../sam0/drivers/usb/usb_sam_l/: usb.c
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../../../../sam0/utils/cmsis/saml21/include/: saml21e16a.h saml21j16a.h saml21g18a.h saml21.h saml21j18a.h saml21g17a.h saml21g16a.h saml21j17a.h saml21e17a.h saml21e15a.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../../../../sam0/utils/cmsis/saml21/include/instance/: ac.h tcc2.h tc4.h dac.h osc32kctrl.h gclk.h tc3.h sercom2.h eic.h tc1.h ccl.h rstc.h tal.h dsu.h sercom4.h sercom3.h pac.h usb.h trng.h nvmctrl.h rtc.h adc.h evsys.h supc.h sercom5.h sercom1.h sercom0.h tcc0.h port.h mclk.h tcc1.h oscctrl.h mtb.h opamp.h dmac.h tc2.h aes.h tc0.h pm.h wdt.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../../../../sam0/utils/cmsis/saml21/include/component/: mtb.h pac.h tal.h tcc.h wdt.h supc.h oscctrl.h tc.h nvmctrl.h opamp.h evsys.h dac.h trng.h mclk.h usb.h dmac.h aes.h adc.h port.h sercom.h rstc.h eic.h ccl.h dsu.h pm.h gclk.h rtc.h osc32kctrl.h ac.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../../../../sam0/utils/cmsis/saml21/include/pio/: saml21j18a.h saml21g16a.h saml21j17a.h saml21g17a.h saml21e15a.h saml21e17a.h saml21j16a.h saml21g18a.h saml21e16a.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../../../../../sam0/boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
