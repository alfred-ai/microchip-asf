# IAR project at24macxx_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel ATSAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMV71_XPLAINED_ULTRA; ARM_MATH_CM7=true; __SAMV71Q21__
  ICCARM.CCIncludePath2: ../../../../../../../services/serial/sam_uart; ..; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/utils/fpu; ../../../../../../../services/serial; ../../../../../../../utils; ../../../../../../../../sam/utils/cmsis/samv71/source/templates; ../../../../../../../../sam/boards/samv71_xplained_ultra; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../../sam/drivers/twihs; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../services/twi; ../../../../../../../services/delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../..; ../../../../../../../services/ioport; ../../../../../../../../sam/utils/cmsis/samv71/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at24macxx_example_flash.bin
  ILINK.IlinkOutputFile: at24macxx_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/samv71/samv71q21/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/memory/eeprom/at24macxx
    ../../../: at24macxx.c at24macxx.h
  group common/components/memory/eeprom/at24macxx/example
    ../../: at24macxx_example.c
  group common/components/memory/eeprom/at24macxx/example/samv71q21_samv71_xplained_ultra
    ../: conf_uart_serial.h conf_board.h conf_clock.h
  group common/components/memory/eeprom/at24macxx/example/samv71q21_samv71_xplained_ultra/iar
    ./: asf.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/services/delay
    ../../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/samv71
    ../../../../../../../services/clock/samv71/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/twi
    ../../../../../../../services/twi/: twihs_slave.h twihs_master.h
  group common/services/twi/sam_twihs
    ../../../../../../../services/twi/sam_twihs/: twihs_master.h twihs_slave.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/boards/samv71_xplained_ultra
    ../../../../../../../../sam/boards/samv71_xplained_ultra/: init.c led.h samv71_xplained_ultra.h
  group sam/drivers/twihs
    ../../../../../../../../sam/drivers/twihs/: twihs.c twihs.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samv71/source/templates
    ../../../../../../../../sam/utils/cmsis/samv71/source/templates/: system_samv71.c system_samv71.h
  group sam/utils/cmsis/samv71/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/samv71/source/templates/iar/: startup_samv71.c
  group sam/utils/cmsis/samv71/include
    ../../../../../../../../sam/utils/cmsis/samv71/include/: samv71q19.h samv71j19.h samv71n21.h samv71j21.h samv71n19.h samv71.h samv71q21.h samv71q20.h samv71n20.h samv71j20.h
  group sam/utils/cmsis/samv71/include/instance
    ../../../../../../../../sam/utils/cmsis/samv71/include/instance/: tc3.h twihs2.h trng.h isi.h piob.h ssc.h pwm0.h sdramc.h wdt.h tc0.h icm.h utmi.h uart3.h acc.h pmc.h hsmci.h piod.h usart0.h rtc.h qspi.h afec0.h gpbr.h rtt.h smc.h mcan0.h uart2.h usbhs.h uart4.h chipid.h matrix.h uart1.h usart2.h dacc.h spi1.h afec1.h efc.h uart0.h mcan1.h pioc.h gmac.h supc.h twihs0.h tc2.h usart1.h spi0.h pioa.h rswdt.h xdmac.h rstc.h pwm1.h mlb.h tc1.h pioe.h aes.h twihs1.h
  group sam/utils/cmsis/samv71/include/pio
    ../../../../../../../../sam/utils/cmsis/samv71/include/pio/: samv71j21.h samv71j20.h samv71q19.h samv71q20.h samv71j19.h samv71q21.h samv71n21.h samv71n19.h samv71n20.h
  group sam/utils/cmsis/samv71/include/component
    ../../../../../../../../sam/utils/cmsis/samv71/include/component/: gmac.h usart.h twihs.h isi.h pmc.h uart.h qspi.h dacc.h trng.h chipid.h gpbr.h pwm.h acc.h smc.h rtt.h aes.h rtc.h hsmci.h utmi.h xdmac.h icm.h supc.h matrix.h sdramc.h spi.h usbhs.h rstc.h efc.h pio.h afec.h mcan.h ssc.h tc.h wdt.h rswdt.h mlb.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
